# Keil uVision project std.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: std
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\std_lib;.\STM32F0xx_StdPeriph_Driver;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS;.\CMSIS\Device\ST\STM32F0xx;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./STM32F0xx_StdPeriph_Driver/: startup_stm32f051.s
  group User
    ./User/: main.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group StdPeriph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c stm32f0xx_usart.c
software components: CMSIS:CORE 5.1.2
